# file: Hal_template.ioc
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Mcu.Family=STM32F4
Mcu.Name=STM32F405RGTx
Mcu.Package=LQFP64
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=MDK-ARM V5.27
RCC.AHBFreq_Value=16000000
RCC.APB1Freq_Value=16000000
RCC.APB2Freq_Value=16000000
RCC.CortexFreq_Value=16000000
RCC.HSE_VALUE=25000000
RCC.HSI_VALUE=16000000
RCC.LSE_VALUE=32768
RCC.SYSCLKFreq_VALUE=16000000
RCC.VCOOutputFreq_Value=192000000
board=custom

// file: Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * <h2><center>&copy; Copyright (c) 2020 STMicroelectronics.
  * All rights reserved.</center></h2>
  *
  * This software component is licensed by ST under BSD 3-Clause license,
  * the "License"; You may not use this file except in compliance with the
  * License. You may obtain a copy of the License at:
  *                        opensource.org/licenses/BSD-3-Clause
  *
  ******************************************************************************
  */
/* USER CODE END Header */

#include "main.h"
//#include "adc.h"
//#include "dma.h"
#include "usart.h"
#include "gpio.h"
#include "tim.h"
#include "bsp_can.h"
#include "temp_pres_drv.h"
#include "bsp_input_ai.h"
#include "bsp_input_di.h"
#include "spi_flash.h"
#include "ccp.h"
#include "tle7242.h"
#include "fm25cl64b.h"
#include "pi.h"
#include "led.h"
#include "mcp2515.h"
#include "can_queue.h"
#include "dac.h"
#include "bsp_user.h"
#include "fm24cl64b_i2c.h"
#include "bsp_output_do.h"
#include "can_mcp2515.h"
#include "bsp_output_docc.h"
#include "exti.h"
#include "bsp_test.h"

#include "bsp_main.h"

void SystemClock_Config(void);

unsigned int p_counter = 0;	//primitive counter
unsigned char receive_buffer[8];	//receive buffer

/* USER CODE END 0 */

extern int ccpBootReceiveCro (unsigned char *msg);
extern int ccpBootTransmitCrmPossible( void );
extern void _timer_0(void);
extern int flag;
extern void init_timer_0 (unsigned long millisec);
extern tag_TLE_CONFIG_RECORD tag_tle_record;

int main(void)
{
	/* USER CODE END 1 */

	/* MCU Configuration--------------------------------------------------------*/

	/* Reset of all peripherals, Initializes the Flash interface and the Systick. */
	HAL_Init();
	SystemClock_Config();

   	Driver_Init();

   //ccpInit();
	API_Manufacturer_Info_Get(PO1);

  printf("record_Version_Number %d\r\n", tag_tle_record.record_Version_Number);
  printf("record_Manuf_ID %d\r\n", tag_tle_record.record_Manuf_ID);

  while (1)
  {

	ADC_Smooth();//AI �ɼ�

    DI_Screen();//DI �ɼ�
	AI_Diagnose_State_Get();//AI1-AI6�����
	bsp_application_task_loop();

	Test_Function_LED();

 #if 0
	if(ccpBootReceiveCro(receive_buffer))
	{   // if new CRO message received,
		ccpCommand(receive_buffer);                 // call ccpCommand
	}

	CCP_DISABLE_INTERRUPT;

	if(ccpBootTransmitCrmPossible())
	{
		ccpSendCallBack();
	}

	CCP_ENABLE_INTERRUPT;

	ccpBackground();

	init_timer_0(10);

	if(flag == 1)
	{
		_timer_0();
		flag = 0;
	}

	MCP2515_CanGet_SendQueue();

	LED1_OFF;
#endif
  }
  /* USER CODE END 3 */
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Configure the main internal regulator output voltage
  */
  __HAL_RCC_PWR_CLK_ENABLE();
  __HAL_PWR_VOLTAGESCALING_CONFIG(PWR_REGULATOR_VOLTAGE_SCALE1);

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
  RCC_OscInitStruct.HSEState = RCC_HSE_ON;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
  RCC_OscInitStruct.PLL.PLLM = 8;
  RCC_OscInitStruct.PLL.PLLN = 336;
  RCC_OscInitStruct.PLL.PLLP = RCC_PLLP_DIV2;
  RCC_OscInitStruct.PLL.PLLQ = 4;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV4;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV2;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_5) != HAL_OK)
  {
    Error_Handler();
  }
}

/* USER CODE END 4 */

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/
